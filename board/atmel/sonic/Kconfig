## board/atmel/sonic/Kconfig
```kconfig
if TARGET_SONIC

config SYS_BOARD
	default "sonic"

config SYS_VENDOR
	default "atmel"

config SYS_CONFIG_NAME
	default "sonic"

endif
```
